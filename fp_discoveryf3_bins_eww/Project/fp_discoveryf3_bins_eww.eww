<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\fp_discoveryf3_bins_eww.ewp</path>
  </project>
  <batchBuild/>
</workspace>


