# IAR project fp_discoveryf3_bins_eww.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F303xC ST STM32F303xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: ..\CMSYS_F3; ..\inc; ..\inc\IMU; ..\inc\init; ..\inc\math; ..\inc\stm32f3_driver; ..\inc\tools
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: fp_discoveryf3_bins_eww.bin
  ILINK.IlinkOutputFile: fp_discoveryf3_bins_eww.out
  ILINK.IlinkIcfFile: D:\work\workspace_EWW\fp_discoveryf3_bins_eww\Project\stm32f30x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group cfg
    ./: startup_stm32f30x.s stm32f30x_flash.icf
  group CMSYS
    ../CMSYS_F3/: arm_common_tables.h arm_math.h core_cm0.h core_cm3.h core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h core_sc000.h core_sc300.h
  group inc
    ../inc/: stm32f30x_conf.h stm32f30x_it.h
  group inc/IMU
    ../inc/IMU/: l3gd20.h lsm303dlhc.h stm32f3_discovery_l3gd20.h stm32f3_discovery_lsm303dlhc.h
  group inc/init
    ../inc/init/: stm32f3_discovery.h sys_init.h
  group inc/math
    ../inc/math/: complementary_filter.h kalman_filter.h
  group inc/tools
    ../inc/tools/: func_tools.h vector.h
  group src
    ../src/: main.c stm32f30x_it.c
  group src/IMU
    ../src/IMU/: l3gd20.c lsm303dlhc.c stm32f3_discovery_l3gd20.c stm32f3_discovery_lsm303dlhc.c
  group src/init
    ../src/init/: stm32f3_discovery.c sys_init.c
  group src/math
    ../src/math/: complementary_filter.c kalman_filter.c
  group src/tools
    ../src/tools/: func_tools.c vector.c
  group ST_LIB/inc
    ../inc/stm32f3_driver/: stm32f30x.h stm32f30x_adc.h stm32f30x_can.h stm32f30x_comp.h stm32f30x_crc.h stm32f30x_dac.h stm32f30x_dbgmcu.h stm32f30x_dma.h stm32f30x_exti.h stm32f30x_flash.h stm32f30x_gpio.h stm32f30x_i2c.h stm32f30x_iwdg.h stm32f30x_misc.h stm32f30x_opamp.h stm32f30x_pwr.h stm32f30x_rcc.h stm32f30x_rtc.h stm32f30x_spi.h stm32f30x_syscfg.h stm32f30x_tim.h stm32f30x_usart.h stm32f30x_wwdg.h system_stm32f30x.h
  group ST_LIB/src
    ../src/stm32f3_driver/: stm32f30x_adc.c stm32f30x_can.c stm32f30x_comp.c stm32f30x_crc.c stm32f30x_dac.c stm32f30x_dbgmcu.c stm32f30x_dma.c stm32f30x_exti.c stm32f30x_flash.c stm32f30x_gpio.c stm32f30x_i2c.c stm32f30x_iwdg.c stm32f30x_misc.c stm32f30x_opamp.c stm32f30x_pwr.c stm32f30x_rcc.c stm32f30x_rtc.c stm32f30x_spi.c stm32f30x_syscfg.c stm32f30x_tim.c stm32f30x_usart.c stm32f30x_wwdg.c system_stm32f30x.c
