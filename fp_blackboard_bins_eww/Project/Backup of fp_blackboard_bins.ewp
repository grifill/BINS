# IAR project Backup of fp_blackboard_bins.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F415RG ST STM32F415RG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ENABLE_PRINT
  ICCARM.CCIncludePath2: ..\inc; ..\inc\GNSS; ..\inc\IMU; ..\inc\init; ..\inc\math; ..\inc\stm32f415_driver; ..\inc\tools; ..\CMSYS_F4
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: fp_blackboard_bins.bin
  ILINK.IlinkOutputFile: fp_blackboard_bins.out
  ILINK.IlinkIcfFile: D:\Diplom\STM32\fp_blackboard_bins_eww\Project\stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group cfg
    ./: startup_stm32f4xx.s stm32f4xx_flash.icf
  group CMSYS
    ../CMSYS_F4/: arm_common_tables.h arm_math.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h core_sc000.h core_sc300.h
  group inc/GNSS
    ../inc/GNSS/: binr_parse.h
  group inc/IMU
    ../inc/IMU/: l3g4200d_driver.h lsm303dlhc_driver.h
  group inc/init
    ../inc/IMU/: mems.h
    ../inc/init/: stm32f4xx_conf.h stm32f4xx_it.h sys_init.h
  group inc/tools
    ../inc/tools/: func_tools.h usart_tools.h
  group src
    ../src/: main.c stm32f4xx_it.c
  group src/GNSS
    ../src/GNSS/: binr_parse.c
  group src/IMU
    ../src/IMU/: l3g4200d_driver.c lsm303dlhc_driver.c mems.c
  group src/init
    ../src/init/: sys_init.c
  group src/tools
    ../src/tools/: func_tools.c usart_tools.c
  group STLIB/inc
    ../inc/stm32f415_driver/: misc.h stm32f4xx.h stm32f4xx_adc.h stm32f4xx_can.h stm32f4xx_crc.h stm32f4xx_cryp.h stm32f4xx_dac.h stm32f4xx_dbgmcu.h stm32f4xx_dcmi.h stm32f4xx_dma.h stm32f4xx_exti.h stm32f4xx_flash.h stm32f4xx_fsmc.h stm32f4xx_gpio.h stm32f4xx_hash.h stm32f4xx_i2c.h stm32f4xx_iwdg.h stm32f4xx_pwr.h stm32f4xx_rcc.h stm32f4xx_rng.h stm32f4xx_rtc.h stm32f4xx_sdio.h stm32f4xx_spi.h stm32f4xx_syscfg.h stm32f4xx_tim.h stm32f4xx_usart.h stm32f4xx_wwdg.h system_stm32f4xx.h
  group STLIB/src
    ../src/stm32f415_driver/: stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_misc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c system_stm32f4xx.c
